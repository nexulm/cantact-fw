# Keil uVision project CANtact.uvprojx, settings and files
target CANtact-042C6 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F042C6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x1800) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: CANtact
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: HSI48_VALUE=48000000 HSE_VALUE=8000000 CANTACT_BUILD_NUMBER=0 STM32F042x6
  c include: ..\Inc;..\Drivers\STM32F0xx_HAL_Driver\Inc;..\Middlewares/ST/STM32_USB_Device_Library/Core/Inc;..\Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32F0xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group src
    ../Src/: startup_stm32f042.s startup_stm32f072.s system_stm32f0xx.c main.c stm32f0xx_hal_msp.c stm32f0xx_it.c slcan.c can.c ring_buffer.c
  group USBCDC
    ../Src/: usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
  group USB
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c usbd_core.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_can.c stm32f0xx_hal_cortex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_pcd.c stm32f0xx_hal_pcd_ex.c
target CANtact-072C8 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F072C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: CANtact
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: HSI48_VALUE=48000000 HSE_VALUE=8000000 CANTACT_BUILD_NUMBER=0 STM32F072xB
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
